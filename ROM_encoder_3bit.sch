v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -630 -310 -440 -310 {
lab=T2}
N -620 -190 -440 -190 {
lab=T2}
N -620 -310 -620 -190 {
lab=T2}
N -610 -210 -440 -210 {
lab=T3}
N -610 -210 -610 -100 {
lab=T3}
N -610 -100 -440 -100 {
lab=T3}
N -600 -120 -440 -120 {
lab=T4}
N -590 -10 -440 -10 {
lab=T4}
N -590 -120 -590 -10 {
lab=T4}
N -580 -30 -440 -30 {
lab=T5}
N -580 -30 -580 90 {
lab=T5}
N -580 90 -440 90 {
lab=T5}
N -570 70 -440 70 {
lab=T6}
N -570 190 -440 190 {
lab=T6}
N -570 70 -570 190 {
lab=T6}
N -560 170 -440 170 {
lab=T7}
N -560 170 -560 290 {
lab=T7}
N -560 290 -440 290 {
lab=T7}
N -140 310 40 310 {
lab=VGND}
N 40 310 40 320 {
lab=VGND}
N 40 -270 40 310 {
lab=VGND}
N -140 -270 40 -270 {
lab=VGND}
N -140 -170 40 -170 {
lab=VGND}
N -140 -80 40 -80 {
lab=VGND}
N -140 10 40 10 {
lab=VGND}
N -140 110 40 110 {
lab=VGND}
N -140 210 40 210 {
lab=VGND}
N -20 -340 -20 270 {
lab=VPWR}
N -140 270 -20 270 {
lab=VPWR}
N -140 170 -20 170 {
lab=VPWR}
N -140 70 -20 70 {
lab=VPWR}
N -140 -30 -20 -30 {
lab=VPWR}
N -140 -120 -20 -120 {
lab=VPWR}
N -140 -210 -20 -210 {
lab=VPWR}
N -140 -310 -20 -310 {
lab=VPWR}
N -540 270 -440 270 {
lab=GND}
N -540 270 -540 310 {
lab=GND}
N 500 -540 500 -500 {
lab=VPWR}
N 500 -540 680 -540 {
lab=VPWR}
N 800 -540 800 -500 {
lab=VPWR}
N 680 -540 800 -540 {
lab=VPWR}
N 650 -540 650 -500 {
lab=VPWR}
N 500 -500 500 -470 {
lab=VPWR}
N 650 -500 650 -470 {
lab=VPWR}
N 800 -500 800 -470 {
lab=VPWR}
N 500 -440 500 310 {
lab=#net1}
N 650 -440 650 310 {
lab=#net2}
N 800 -440 800 310 {
lab=#net3}
N -140 -290 820 -290 {
lab=#net4}
N -140 -190 820 -190 {
lab=#net5}
N -140 -100 820 -100 {
lab=#net6}
N -140 -10 820 -10 {
lab=#net7}
N -140 90 820 90 {
lab=#net8}
N -140 190 820 190 {
lab=#net9}
N -140 290 820 290 {
lab=#net10}
N 40 310 380 310 {
lab=VGND}
N 380 310 380 700 {
lab=VGND}
N 380 700 760 700 {
lab=VGND}
N 760 610 760 700 {
lab=VGND}
N 610 610 610 700 {
lab=VGND}
N 460 610 460 700 {
lab=VGND}
N 500 610 500 670 {
lab=VPWR}
N 650 610 650 670 {
lab=VPWR}
N 800 610 800 670 {
lab=VPWR}
N -20 270 -20 730 {
lab=VPWR}
N -20 730 800 730 {
lab=VPWR}
N 800 670 800 730 {
lab=VPWR}
N 650 670 650 730 {
lab=VPWR}
N 500 670 500 730 {
lab=VPWR}
N 400 -470 460 -470 {
lab=VGND}
N 400 -470 400 -380 {
lab=VGND}
N 400 -380 760 -380 {
lab=VGND}
N 760 -470 760 -380 {
lab=VGND}
N -20 -540 -20 -340 {
lab=VPWR}
N -20 -540 500 -540 {
lab=VPWR}
N 610 -470 610 -380 {
lab=VGND}
N 40 -380 400 -380 {
lab=VGND}
N 40 -380 40 -270 {
lab=VGND}
N 410 -330 410 -290 {
lab=#net4}
N 450 -360 500 -360 {
lab=#net1}
N 600 -260 650 -260 {
lab=#net2}
N 560 -230 560 -190 {
lab=#net5}
N 410 -140 410 -100 {
lab=#net6}
N 450 -170 500 -170 {
lab=#net1}
N 560 -140 560 -100 {
lab=#net6}
N 600 -170 650 -170 {
lab=#net2}
N 710 -50 710 -10 {
lab=#net7}
N 750 -80 800 -80 {
lab=#net3}
N 710 50 710 90 {
lab=#net8}
N 750 20 800 20 {
lab=#net3}
N 410 50 410 90 {
lab=#net8}
N 450 20 500 20 {
lab=#net1}
N 410 240 410 290 {
lab=#net10}
N 450 210 500 210 {
lab=#net1}
N 560 240 560 290 {
lab=#net10}
N 600 210 650 210 {
lab=#net2}
N 710 240 710 290 {
lab=#net10}
N 750 210 800 210 {
lab=#net3}
N 450 -300 880 -300 {
lab=GND}
N 880 -300 880 280 {
lab=GND}
N 600 180 750 180 {
lab=GND}
N 750 180 880 180 {
lab=GND}
N 560 150 560 190 {
lab=#net9}
N 600 120 650 120 {
lab=#net2}
N 710 150 710 190 {
lab=#net9}
N 750 120 800 120 {
lab=#net3}
N 450 80 750 80 {
lab=GND}
N 750 80 880 80 {
lab=GND}
N 750 -20 880 -20 {
lab=GND}
N 450 -110 600 -110 {
lab=GND}
N 600 -110 880 -110 {
lab=GND}
N 600 -200 880 -200 {
lab=GND}
N 600 150 600 180 {
lab=GND}
N 750 150 750 180 {
lab=GND}
N 750 50 750 80 {
lab=GND}
N 450 50 450 80 {
lab=GND}
N 750 -50 750 -20 {
lab=GND}
N 600 -140 600 -110 {
lab=GND}
N 450 -140 450 -110 {
lab=GND}
N 600 -230 600 -200 {
lab=GND}
N 450 -330 450 -300 {
lab=GND}
N 450 240 450 270 {
lab=GND}
N 600 240 600 270 {
lab=GND}
N 750 240 750 270 {
lab=GND}
N 450 270 880 270 {
lab=GND}
N 880 280 880 300 {}
C {/home/huydq/edge_cell.sym} -290 -290 0 0 {name=x1}
C {/home/huydq/edge_cell.sym} -290 -190 0 0 {name=x2}
C {/home/huydq/edge_cell.sym} -290 -100 0 0 {name=x3}
C {/home/huydq/edge_cell.sym} -290 -10 0 0 {name=x4}
C {/home/huydq/edge_cell.sym} -290 90 0 0 {name=x5}
C {/home/huydq/edge_cell.sym} -290 190 0 0 {name=x6}
C {/home/huydq/edge_cell.sym} -290 290 0 0 {name=x7}
C {devices/ipin.sym} -440 -290 0 0 {name=p2 lab=T1}
C {devices/ipin.sym} -630 -310 0 0 {name=p3 lab=T2}
C {devices/ipin.sym} -610 -210 0 0 {name=p4 lab=T3}
C {devices/ipin.sym} -600 -120 0 0 {name=p5 lab=T4}
C {devices/ipin.sym} -580 -30 0 0 {name=p6 lab=T5}
C {devices/ipin.sym} -570 70 0 0 {name=p7 lab=T6}
C {devices/ipin.sym} -560 170 0 0 {name=p8 lab=T7}
C {devices/iopin.sym} 40 320 1 0 {name=p128 lab=VGND}
C {devices/gnd.sym} -270 4820 0 0 {name=l2 lab=GND}
C {devices/gnd.sym} -540 310 0 0 {name=l3 lab=GND}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 480 -470 0 0 {name=M7
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 630 -470 0 0 {name=M1
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 780 -470 0 0 {name=M2
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/iopin.sym} 650 -540 3 0 {name=p1 lab=VPWR}
C {/home/huydq/my_inv_1.sym} 480 460 1 0 {name=x8}
C {/home/huydq/my_inv_1.sym} 630 460 1 0 {name=x9}
C {/home/huydq/my_inv_1.sym} 780 460 1 0 {name=x10}
C {devices/opin.sym} 480 610 1 0 {name=p9 lab=B0}
C {devices/opin.sym} 630 610 1 0 {name=p10 lab=B1}
C {devices/opin.sym} 780 610 1 0 {name=p11 lab=B2}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 430 -330 0 0 {name=M3
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 580 -230 0 0 {name=M4
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 430 -140 0 0 {name=M5
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 580 -140 0 0 {name=M6
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 730 -50 0 0 {name=M8
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 430 50 0 0 {name=M9
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 730 50 0 0 {name=M10
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 580 150 0 0 {name=M11
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 730 150 0 0 {name=M12
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 430 240 0 0 {name=M13
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 580 240 0 0 {name=M14
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 730 240 0 0 {name=M15
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 880 300 0 0 {name=l1 lab=GND}
